# Repository zerberros/Audio_interfaces

File README.md:

# Audio_interfaces
Collection of audio interfaces

## CM6631 audio USB interface 

* USB2.0 true high-speed audio processor.

## CC85XX wireless interface

* (planned)

## KiCad design USB_interface_board_CM6631/USB_interface_board.kicad_pcb

Parts:
C31, C32, C35: 10u; c_elec_5x5.3
C33, C34: 18p; C_1206_HandSoldering
C36, C37: 0.01U; C_1206_HandSoldering
LOGO1: CERN OHL V1.0 license; Symbol_OSHW-Logo_SilkScreen
P2, P3, P8: CONN_01X02; Pin_Header_Straight_1x02
P4, P5, P12, P19, P20, P21, P23: CONN_02X05; IDC_Header_Straight_10pins
P6, P11, P14, P18, P22: CONN_01X03; Pin_Header_Straight_1x03
P7, P15, P16: CONN_01X01; Pin_Header_Straight_1x01
P10: USB_B
R23: 12k 1%; R_1206_HandSoldering
U9: MCP1700T-3302E/TT; SOT-23
U10: CM6631; LQFP-100_14x14mm_Pitch0.5mm
U11: SST39VF512; TSSOP-32_14x8mm_Pitch0.65mm
X1, X2: IQXO/7X; Oscillator
Y2: 12MHz; Crystal_HC49-SD_SMD

Connections:
+3V3: C32.1, C36.1, C37.1, P2.1, P6.1, P12.3, U9.2, U10.2 (VCCHSRT), U10.7 (VCCA_U20), U10.9 (VCC3V), U10.29 (VCC3V), U10.53 (VCC3V), U10.73 (VCC3V), U10.97 (VCC3V), U11.8 (VDD), X1.4, X2.4
+5V: C31.1, P10.1 (VCC), U9.3
/Sheet5744DB9D/USB_N: P10.2 (D-), U10.5 (USBD_N)
/Sheet5744DB9D/USB_P: P10.3 (D+), U10.6 (USBD_P)
GNDA: P10.4 (GND), P10.5 (shield), R23.2, U10.3 (GNDHSRT), U10.8 (GNDA_U20)
GNDD: C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, P2.2, P3.1, P4.1, P5.1, P6.3, P8.1, P11.1, P12.1, P14.1, P18.1, P19.1, P20.1, P21.1, P22.1, P23.1, U9.1, U10.11 (GND), U10.18 (GND), U10.39 (GND), U10.61 (GND), U10.99 (XTEST), U11.24 (VSS), X1.2, X2.2
GPIO_1: P23.2, U10.54 (XGPIO_1)
GPIO_2: P23.3, U10.49 (XGPIO_2)
GPIO_3: P23.4, U10.50 (XGPIO_3)
GPIO_4: P23.5, U10.51 (XGPIO_4)
GPIO_5: P23.6, U10.52 (XGPIO_5)
GPIO_6: P23.7, U10.58 (XGPIO_6)
GPIO_7: P23.8, U10.59 (XGPIO_7)
GPIO_8: P23.9, U10.60 (XGPIO_8)
GPIO_9: P23.10, U10.62 (XGPIO_9)
unnamed: C33.1, U10.100 (XSCI), Y2.1
unnamed: C34.1, U10.1 (XSCO), Y2.2
unnamed: C35.1, U10.10 (VCC)
unnamed: P3.2, X1.1
unnamed: P4.3, U10.88 (X2DAC_SDOUT)
unnamed: P4.5, U10.87 (X2DAC_SCLK)
unnamed: P4.7, U10.86 (X2DAC_LRCK)
unnamed: P4.9, U10.85 (X2DAC_MCLK)
unnamed: P5.3, U10.89 (XMDAC_SDOUT0)
unnamed: P5.5, U10.93 (XMDAC_SCLK)
unnamed: P5.7, U10.94 (XMDAC_LRCK)
unnamed: P5.9, U10.95 (XMDAC_MCLK)
unnamed: P6.2, U10.96 (XSELF_POWER)
unnamed: P7.1, U10.98 (XRST)
unnamed: P8.2, X2.1
unnamed: P11.2, U10.64 (XMSCL)
unnamed: P11.3, U10.63 (XMSDA)
unnamed: P12.2, U10.12 (XGPI_0)
unnamed: P12.4, U10.13 (XGPI_1)
unnamed: P12.6, U10.14 (XGPI_2)
unnamed: P12.8, U10.15 (XGPI_3)
unnamed: P12.9, U10.17 (XGPI_5)
unnamed: P12.10, U10.16 (XGPI_4)
unnamed: P14.2, U10.57 (XSSCL)
unnamed: P14.3, U10.56 (XSSDA)
unnamed: P15.1, U10.19 (XPWDN)
unnamed: P16.1, U10.55 (XRSTO)
unnamed: P18.2, U10.23 (XD1)
unnamed: P18.3, U10.22 (XD0)
unnamed: P19.2, U10.24 (XHDA_BCLK)
unnamed: P19.4, U10.25 (XHDA_SDI)
unnamed: P19.6, U10.26 (XHDA_SYNC)
unnamed: P19.8, U10.27 (XHDA_RST)
unnamed: P19.10, U10.28 (XHDA_SDO)
unnamed: P20.3, U10.30 (XMADC_SDIN0)
unnamed: P20.5, U10.31 (XMADC_SCLK)
unnamed: P20.7, U10.33 (XMADC_LRCK)
unnamed: P20.9, U10.32 (XMADC_MCLK)
unnamed: P21.3, U10.34 (X2ADC_SDIN)
unnamed: P21.5, U10.35 (X2ADC_SCLK)
unnamed: P21.7, U10.36 (X2ADC_LRCK)
unnamed: P21.9, U10.37 (X2ADC_MCLK)
unnamed: P22.2, U10.38 (XSPDIFO_0)
unnamed: P22.3, U10.40 (XSPDIFI_0)
unnamed: R23.1, U10.4 (RREF)
unnamed: U10.20 (XD6), X1.3
unnamed: U10.21 (XD7), X2.3
XPEE_A0: U10.65 (XPEE_A0), U11.20 (A0)
XPEE_A1: U10.66 (XPEE_A1), U11.19 (A1)
XPEE_A2: U10.67 (XPEE_A2), U11.18 (A2)
XPEE_A3: U10.68 (XPEE_A3), U11.17 (A3)
XPEE_A4: U10.69 (XPEE_A4), U11.16 (A4)
XPEE_A5: U10.70 (XPEE_A5), U11.15 (A5)
XPEE_A6: U10.71 (XPEE_A6), U11.14 (A6)
XPEE_A7: U10.72 (XPEE_A7), U11.13 (A7)
XPEE_A8: U10.74 (XPEE_A8), U11.3 (A8)
XPEE_A9: U10.75 (XPEE_A9), U11.2 (A9)
XPEE_A10: U10.76 (XPEE_A10), U11.31 (A10)
XPEE_A11: U10.77 (XPEE_A11), U11.1 (A11)
XPEE_A12: U10.78 (XPEE_A12), U11.12 (A12)
XPEE_A13: U10.79 (XPEE_A13), U11.4 (A13)
XPEE_A14: U10.80 (XPEE_A14), U11.5 (A14)
XPEE_A15: U10.81 (XPEE_A15), U11.11 (A15)
XPEE_CEN: U10.82 (XPEE_CEN), U11.30 (~CE~)
XPEE_D0: U10.41 (XPEE_D0), U11.21 (DQ0)
XPEE_D1: U10.42 (XPEE_D1), U11.22 (DQ1)
XPEE_D2: U10.43 (XPEE_D2), U11.23 (DQ2)
XPEE_D3: U10.44 (XPEE_D3), U11.25 (DQ3)
XPEE_D4: U10.45 (XPEE_D4), U11.26 (DQ4)
XPEE_D5: U10.46 (XPEE_D5), U11.27 (DQ5)
XPEE_D6: U10.47 (XPEE_D6), U11.28 (DQ6)
XPEE_D7: U10.48 (XPEE_D7), U11.29 (DQ7)
XPEE_RDN: U10.84 (XPEE_RDN), U11.32 (~OE~)
XPEE_WRN: U10.83 (XPEE_WRN), U11.7 (~WE~)

Notes on the sheet:
Consumo: CM6631: 40mA Memory: 9mA
XSELF_POWER: H: self powered L: Bus powered
2-Wire Master Serial Bus (I2C)
2-Wire Slave Serial Bus (I2C)
2-channel I2S DAC_1 Interface (PDMA_A)
2-channel I2S DAC_2 Interface (PDMA_C)
2-channel I2S ADC_1 Interface (RDMA_A)
2-channel I2S ADC_2 Interface (RDMA_C)
S/PDIF I/O
High-Definition Audio Interface
GPI
Midi Interface

Board: 2 copper layers, 89.5 x 50.0 mm, 34 parts (22 on the bottom side), 89 nets.

Other parts of the board:
OHL V1.0 license: CERN OHL V1.0 license; Symbol_OSHW-Logo_SilkScreen

## Commit log

2021-04-11 Added USB interfase
